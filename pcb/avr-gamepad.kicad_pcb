# Repository SiloCityLabs/Cuttlephone

File README.md:

# Cuttlephone
Cuttlephone is phone case generator and gamepad system for 3D printing. This is the source code. [Get premade 3D models and print tutorials on the website](https://cuttlephone.com/)

# Features
 - hard plastic (PLA+, ABS, PETG) or flexible (TPU)
 - phone case mode
 - universal phone clamp mode
 - Switch Joy-Con rails
 - Razer Junglecat rails
 
# How to use phone case generator
 - install [OpenSCAD](https://openscad.org/downloads.html) version 2021.01 or greater
 - Download the code and its dependencies using the git command line: `git clone https://github.com/SiloCityLabs/Cuttlephone.git --recurse-submodules`
 - open the file "phone_case.scad" to use the GUI

# Build scripts
 - in bash run `sh build.sh` to create all variants for all phones
 - GitHub Actions uploads those files to a [GitHub Release](https://github.com/SiloCityLabs/Cuttlephone/releases)

# How to run the docs blog locally

### With Docker:
 - `cd docs`
 - `docker compose up --build`
 - open http://127.0.0.1:4000/

### With Ruby on the host:
 - install Ruby 3.3 or newer, gem, and bundle
 - `cd docs`
 - `bundle install`
 - `sh run.sh`
 - watch the console for something like this: `Server address: http://127.0.0.1:4000/`

A GitHub token is optional. `jekyll-remote-theme` downloads the theme through the GitHub API, which is rate limited to 60 requests an hour without one. If you hit that limit:
- generate a token at https://github.com/settings/tokens/new with the scope *public_repo*
- copy `docs/.env.example` to `docs/.env`
- add token to `docs/.env`

# Build logs 

You can follow progress here:
 - [HackADay.io project log](https://hackaday.io/project/165606-cuttlephone-gamepad-phone-case)
 - [SiloCityLabs project blog / newsletter](https://silocitylabs.com/categories/projects/)
 - [SiloCityLabs Twitter](https://twitter.com/silocitylabs)

# Roadmap

...

Licensed under Creative Commons CC-BY-SA 4.0

## KiCad design pcb/avr-gamepad.kicad_pcb

Parts:
C1, C5: 0.1uF; C_0603_1608Metric
C2, C6: 1uF; C_0603_1608Metric
C3, C4: 22pF; C_0603_1608Metric
D1, D2: LED; LED_0603_1608Metric
D3, D4, D5, D6, D7, D8, D9, D11, D12, D13, D14, D15, D17, D18: 1N4148; D_0603_1608Metric
J1, J2: Conn_01x06; Hirose_FH12-6S-0.5SH_1x06-1MP_P0.50mm_Horizontal
J3, J4: Conn_01x05; 5051100592
P1: USB_C_Plug; USB_C_Plug_Molex_105444
R1, R2: 22; R_0603_1608Metric
R3, R4: 5.1k; R_0603_1608Metric
R5, R6, R7, R8, R9, R10: 1K; R_0603_1608Metric
SW1: RESET; Small
SW2: Right; Dpad_Large_tapered
SW3: Up; Dpad_Large_tapered
SW4: Down; Dpad_Large_tapered
SW6: Select; Small
SW7: L1; TL3330
SW8: R1; TL3330
SW10: R2; TL3330
SW11: A; Large_tapered
SW13: Left; Dpad_Large_tapered
SW14: L2; TL3330
SW16: B; Large_tapered
SW17: Start; Small
SW18: Y; Large_tapered
SW19: X; Large_tapered
U1: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
U2, U3: PCF8574; SO16W
Y1: Crystal_GND24; Crystal_SMD_SeikoEpson_FA238-4Pin_3.2x2.5mm

Connections:
+5V: C1.1, C2.1, J2.5, J3.1, P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS), R7.1, R8.1, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC), U3.16 (VDD)
/Col1: SW8.1, SW10.1, SW17.1, U3.7 (P3)
/Col2: SW11.1, SW16.1, U3.9 (P4)
/Col3: SW18.1, SW19.1, U3.10 (P5)
/ColL1: SW7.1, SW13.1, SW14.1, U2.7 (P3)
/ColL2: SW3.1, SW4.1, U2.9 (P4)
/ColL3: SW2.1, SW6.1, U2.10 (P5)
/D+: R1.1, U1.4 (D+)
/D-: R2.1, U1.3 (D-)
/GND_L: D2.2 (A), J1.6, J4.4, U2.8 (VSS)
/JoyLeftX: J2.3, U1.39 (PF4)
/JoyLeftX_L: J1.3, J4.5
/JoyLeftY: J2.4, U1.38 (PF5)
/JoyLeftY_L: J1.4, J4.2
/JoyRightX: J3.5, U1.37 (PF6)
/JoyRightY: J3.2, U1.36 (PF7)
/L3: J4.3, U2.11 (P6)
/R3: J3.3, U3.11 (P6)
/Row1: D11.1 (K), D14.1 (K), D17.1 (K), U3.4 (P0)
/Row2: D12.1 (K), D15.1 (K), D18.1 (K), U3.5 (P1)
/Row3: D13.1 (K), U3.6 (P2)
/RowL1: D3.1 (K), D4.1 (K), D8.1 (K), U2.4 (P0)
/RowL2: D5.1 (K), D7.1 (K), D9.1 (K), U2.5 (P1)
/RowL3: D6.1 (K), U2.6 (P2)
/SCL: J2.2, R7.2, U1.18 (PD0), U3.14 (SCL)
/SCL_L: J1.2, R10.2, U2.14 (SCL)
/SDA: J2.1, R8.2, U1.19 (PD1), U3.15 (SDA)
/SDA_L: J1.1, R9.2, U2.15 (SDA)
/VCC_L: J1.5, J4.1, R9.1, R10.1, U2.16 (VDD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D1.2 (A), J2.6, J3.4, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), P1.S1 (SHIELD), R3.2, R4.2, SW1.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), U3.1 (A0), U3.2 (A1), U3.3 (A2), U3.8 (VSS), Y1.2, Y1.4
unnamed: C3.1, U1.17 (XTAL1), Y1.1
unnamed: C4.1, U1.16 (XTAL2), Y1.3
unnamed: C5.1, U1.42 (AREF)
unnamed: C6.1, U1.6 (UCAP)
unnamed: D1.1 (K), R5.1
unnamed: D2.1 (K), R6.1
unnamed: D3.2 (A), SW6.2
unnamed: D4.2 (A), SW7.2
unnamed: D5.2 (A), SW13.2
unnamed: D6.2 (A), SW14.2
unnamed: D7.2 (A), SW2.2
unnamed: D8.2 (A), SW3.2
unnamed: D9.2 (A), SW4.2
unnamed: D11.2 (A), SW17.2
unnamed: D12.2 (A), SW8.2
unnamed: D13.2 (A), SW10.2
unnamed: D14.2 (A), SW11.2
unnamed: D15.2 (A), SW16.2
unnamed: D17.2 (A), SW19.2
unnamed: D18.2 (A), SW18.2
unnamed: P1.A7 (D-), R2.2
unnamed: P1.B5 (VCONN), R3.1
unnamed: R5.2, U3.12 (P7)
unnamed: R6.2, U2.12 (P7)
unnamed: SW1.2, U1.13 (~RESET)

Notes on the sheet:
Power Decoupling

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
Board: 2 copper layers, 56 parts (43 on the bottom side), 56 nets, no tracks yet.

## KiCad design pcb/MCP23008/MCP23008.kicad_pcb

File pcb/MCP23008/README.md:

Breakout board for the MCP23008 IO expander

Board: 2 copper layers, 27.9 x 26.7 mm, 8 parts (0 on the bottom side), 15 nets.

Parts:
J1: A0; PinSocket_1x03_P2.54mm_Vertical
J2: A1; PinSocket_1x03_P2.54mm_Vertical
J3: A2; PinSocket_1x03_P2.54mm_Vertical
J4: IO; PinSocket_1x08_P2.54mm_Vertical
J5: Input; PinSocket_1x04_P2.54mm_Vertical
R1, R2: 1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
U1: MCP23008-E_P; DIP-18_W7.62mm

Connections:
/SCL: J5.3, R1.2, U1.1
/SDA: J5.2, R2.2, U1.2
GND: J1.3, J2.3, J3.3, J5.4, U1.8, U1.9
unnamed: J1.2, U1.3
unnamed: J2.2, U1.4
unnamed: J3.2, U1.5
unnamed: J4.1, U1.10
unnamed: J4.2, U1.11
unnamed: J4.3, U1.12
unnamed: J4.4, U1.13
unnamed: J4.5, U1.14
unnamed: J4.6, U1.15
unnamed: J4.7, U1.16
unnamed: J4.8, U1.17
VCC: J1.1, J2.1, J3.1, J5.1, R1.1, R2.1, U1.6, U1.18

## KiCad design avr-gamepad.kicad_pcb

Parts:
C1, C5: 0.1uF; C_0805_2012Metric
C2, C6: 1uF; C_0805_2012Metric
C3, C4: 10pF; C_0805_2012Metric
D1, D2: LED; LED_0805_2012Metric
J1, J2: Conn_01x08; Hirose_FH12-8S-0.5SH_1x08-1MP_P0.50mm_Horizontal
J3: Conn_01x08_Female; PinHeader_1x08_P2.54mm_Vertical
P1: USB_C_Plug_USB2.0; USB_C_Plug_Molex_105444
R1, R2: 22; R_0805_2012Metric
R3, R4: 5.1k; R_0805_2012Metric
R5, R6: 1K; R_0805_2012Metric
SW1: RESET; Small
SW2: R; Large_tapered
SW3: X; Large_tapered
SW4: A; Large_tapered
SW5: B; Large_tapered
SW6: Start; Small
SW7: Y; Large_tapered
SW8: Right; Large_tapered
SW9: L; Large_tapered
SW10: Up; Large_tapered
SW11: Down; Large_tapered
SW12: Left; Large_tapered
SW13: Select; Small
SW14: HWB; Small
U1: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
Y1: Crystal_GND24; Crystal_SMD_SeikoEpson_FA238-4Pin_3.2x2.5mm

Connections:
+5V: C1.1, C2.1, P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS), U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)
/pb0-8: SW2.1, U1.8 (PB0)
/pb1-9: SW3.1, U1.9 (PB1)
/pb2-10: SW4.1, U1.10 (PB2)
/pb3-11: SW5.1, U1.11 (PB3)
/pb4-28: J2.3, U1.28 (PB4)
/pb5-29: J2.4, U1.29 (PB5)
/pb6-30: J2.5, U1.30 (PB6)
/pb7-12: SW6.1, U1.12 (PB7)
/pc6-31: J2.6, U1.31 (PC6)
/pc7-32: J2.7, U1.32 (PC7)
/pd0-18: SW7.1, U1.18 (PD0)
/pd1-19: R5.2, U1.19 (PD1)
/pd2-20: J3.1, U1.20 (PD2)
/pd3-21: J3.2, U1.21 (PD3)
/pd4-25: J3.4, U1.25 (PD4)
/pd5-22: J3.3, U1.22 (PD5)
/pd6-26: J2.1, U1.26 (PD6)
/pd7-27: J2.2, U1.27 (PD7)
/pe6-1: U1.1 (PE6)
/pf0-41: U1.41 (PF0)
/pf1-40: U1.40 (PF1)
/pf4-39: J3.8, U1.39 (PF4)
/pf5-38: J3.7, U1.38 (PF5)
/pf6-37: J3.6, U1.37 (PF6)
/pf7-36: J3.5, U1.36 (PF7)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D1.2 (A), J2.8, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), P1.S1 (SHIELD), R3.2, R4.2, SW1.1, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW14.2, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), Y1.2, Y1.4; also elsewhere on the board
unnamed: C3.1, U1.17 (XTAL1), Y1.1
unnamed: C4.1, U1.16 (XTAL2), Y1.3
unnamed: C5.1, U1.42 (AREF)
unnamed: C6.1, U1.6 (UCAP)
unnamed: D1.1 (K), R5.1
unnamed: D2.1 (K), R6.1
unnamed: D2.2 (A), J1.8, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2
unnamed: J1.1, SW13.1
unnamed: J1.2, SW8.1
unnamed: J1.3, SW10.1
unnamed: J1.4, SW11.1
unnamed: J1.5, SW12.1
unnamed: J1.6, SW9.1
unnamed: J1.7, R6.2
unnamed: P1.A5 (CC), R4.1
unnamed: P1.A6 (D+), R1.2
unnamed: P1.A7 (D-), R2.2
unnamed: P1.B5 (VCONN), R3.1
unnamed: R1.1, U1.4 (D+)
unnamed: R2.1, U1.3 (D-)
unnamed 47: SW1.2, U1.13 (~RESET); also elsewhere on the board
unnamed 48: SW14.1, U1.33 (~HWB~/PE2); also elsewhere on the board

Notes on the sheet:
Power Decoupling

Board: 2 copper layers, 55.8 x 44.3 mm, 36 parts (19 on the bottom side), 46 nets.

Other parts of the board:
HWB: HWB; Small
RESET: RESET; Small
mb-2mm-1: mb1; mouse-bite-2mm-slot
mb-2mm-2: mb2; mouse-bite-2mm-slot

Their connections:
GND: HWB.2, RESET.1; also elsewhere on the board
unnamed 47: RESET.2; also elsewhere on the board
unnamed 48: HWB.1; also elsewhere on the board

## Commit log (part)

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2019-07-21 rearrange, reroute, DRC fixes
2019-07-24 tweak silkscreen, add BOM
2019-09-29 begin v2. Remove flex, move components to one side, expand board size, remove excess caps, recess usb connector
2019-09-29 change main pad shape, shuffle things
2019-09-29 reduce outline
2019-09-30 pin swapping and component shuffling
2019-10-01 move footprints to new dir, increase contact size, add squidward
2019-10-02 kill the double sided feature, make it 2 boards, import mousebites
2019-10-03 component relabelling, shuffling around, two-piece board
2019-10-04 add 0.1 in headers, label atmega pins better
2019-10-05 move board outline for each half
2019-10-06 route, more mousebites
2019-10-07 silkscreen credits and art
2019-10-10 no art. Checkpoint before analog
2020-01-02 playing with castellated vias
2020-01-02 move PCB files to a sub directory. Create sub directory for case 3d model
2020-01-02 initial commit of half-working case
2020-01-04 separate body radius from body thickness. Start joycon rail shell
2020-01-04 convert line endings to unix, ruining the git history
2020-01-05 add manual support for joycon rail, cut joycon lock notch
2020-01-10 begin implementing junglecat rails, fix joycon shell thickness, tweak mic cut for joycon rail
2020-01-10 guestimate junglecat cut
2020-01-10 disable test shapes
2020-01-14 tweak gamepad shell triggers, button holes, and faceplate pegs. 45 degree cut PCB corners. test add ffc connector for joystick
2020-01-14 actually add 45 degree corners
2020-01-29 tweaks: screen lip, joycon rail
2020-01-29 kill side_radius_thickness variable, more dimensional tweaks
2020-01-30 readme pic, change screen length to screen lip in customizer
2020-01-31 readme
2020-02-10 make it easier to remove joycon rail support. STL build script. Emboss version info in case
2020-02-14 use json configs in build script, hide junglecat rails until they work
2020-04-06 move configs to single file (the way it should be). Add Pixel 3a support
2020-04-09 initial firmware
2020-04-09 cleanup schematic
2020-04-12 extra screen lip, rounded cut corners to prevent snagging, galaxy s9+ support
2020-04-12 galaxy s9+ rough tweaks
2020-04-12 switched to pcf8574
2020-04-12 mic cut corner rounding, s9+ tweaks
2020-04-13 change left/right on schematic, start arranging pcb, add pcf8574 footprint
2020-04-13 disabled extra buttons, fixed R-L conversion
2020-04-13 swap left/right board sides for fab assembly
2020-04-13 board edge cuts for joystick
2020-04-14 pcb rearranging, placeholder footprint for right angle tact switches
2020-04-15 change triggers to tact switches, add footprint
2020-04-15 mcp folder
2020-04-16 make lib paths relative, add footprints to mcp23008 breakout, chuck into pcbnew
2020-04-16 frame
2020-04-18 route mcp23008
2020-05-03 authors file, config tweaks, corner cut for headphone jack
2020-05-04 change 5-pin ffc to molex
2020-05-05 improve d-pad contacts
2020-05-09 s9 tweaks, fix var named the same as a function
2020-05-20 cleanup and lip tweaks
2020-08-12 build STL cus 3mf rendered weird, fix variable name conflict
2020-08-27 make screen lip less sharp. Add lanyard slot. Fix pixel 3a scren radius
2020-08-27 change mic hole for stiffness. Change bottom speaker cutout for stiffness
2020-09-19 Set theme jekyll-theme-leap-day
2020-09-19 fix geometry calculations with BOSL shapes, add 1x04 FFC, experimental trigger
2020-12-15 junglecat rails work
2020-12-20 tweak cuts and Pixel 3 config
2021-04-01 build all versions of case in build script
2021-04-01 comment out stupid_hack for build script
2021-04-02 improve case_type_override, fix/move pre-commit
2021-04-09 round inside edge, add independent screen corner rounding for better grip
2021-10-31 fix build script importing text. Start osft TPU case
2021-11-01 soft case cuts done
2021-11-07 add support for TPU overhangs. Add side edge debug cut
2021-11-15 add BOSL2 to repo
2021-11-29 make soft buttons
2021-12-12 fix a bunch of soft button logic
2021-12-12 texture power button and volume button
2021-12-13 update build script for soft case
2021-12-13 theme testing
2021-12-15 working on soft rails
2021-12-15 update BOSL2
2021-12-15 Increment version to 0.2. Update code for BOSL2. Round the edges of the junglecat/joycon rail cases more
2021-12-18 update docs
2021-12-18 parse windows newlines better in build script. Installing jekyll
2021-12-20 customizing website and playing with jekyll variables
2021-12-21 update premade models page
2021-12-22 update URLs for github pages
2021-12-22 testing about page
2021-12-22 rearrange
2021-12-22 base url rearrange
2021-12-22 mobile style sheet
2021-12-27 screenshots on website
2021-12-30 allow bottom mic cut, fix newlines and tabs
2022-01-02 fix soft button alignment
2022-01-07 galaxy s9+ measurements
2022-03-08 playing with Galaxy S9 curves, tweak USB port cut
2022-03-08 upgrade KiCad 6.0
2022-03-10 cut guide for junglecat rails
2022-03-10 joycon cut guide
2022-03-11 improve junglecat cut guide
2022-03-11 fix joycon screen cut
2022-04-05 re-learn trig to make a fillet function for S9 case
2022-04-08 fix extra_lip
2022-04-11 galaxy s9 rounding tweaks
2022-04-21 galaxy s9+ tuning, split bottom speakers left/right
2022-04-24 fix the sharp corner on the Galaxy S9+ curved back
2022-04-29 fix build script and bug-workaround variables
2022-04-29 update docs with premade 3MF files
2022-04-29 joycon rail screenshot
2022-05-07 build script updates
2022-05-07 remove gamepad from build script
2022-05-08 hide unfinished gamepad, update docs
2022-05-15 docs
2022-05-16 S9+ tweaks
2022-05-20 fill in button backing
2022-06-12 stick-out joycon rails for thick cases
2022-06-14 refactoring and universal tweaks
2022-06-19 joycon rail and universal tweaks
2022-06-19 rotate option for cases that should be printed vertically
2022-06-19 build models for vertical option
2022-06-19 variable thickness in build script
2022-06-19 publish varying thickness
2022-06-20 universal in docs
2022-06-26 telescopic case
2022-07-04 improve telescoping rail
2022-07-04 publish telescopic
2022-07-10 fix two-piece's name for the build script
2022-07-10 publish two-piece fix
2022-07-10 allow mic cuts on both top and bottom. Put format_json.sh back so I use it more
2022-07-14 allow supports for the soft button cutouts. Xperia 1 III tweaks
2022-07-16 galaxy S9+ tweaks, screen recess, button tweaks, cleanup
2022-07-17 tweaking defaults for customizer precision
2022-07-24 telescopic tweaks. Pixel 6 initial config
2022-10-01 add XL and back-chop telescopic variants
2022-10-01 more font spacing, very small text option
2022-10-02 update version to 0.4. Publish models
2022-10-03 updating build scripts and which cases are displayed on the site
2022-10-03 update configs with build true/false
2022-10-03 build script nonsnese
2022-10-03 hide some models in the build page
2022-10-17 update docs. Tweak joycon vertical support
2022-10-17 build fixed support tower
2022-10-20 update docs, remove old models
2022-10-20 fetch phone_model from JSON array keys
2022-10-21 skip building unneeded models
2022-11-21 move PCB and firmware to new repo
2022-11-21 comments
2022-11-21 refactoring
2022-12-17 Pixel 3 adjustments
2022-12-18 make directory for guides
2022-12-19 add generator guide
2023-01-26 add SVG logo. Add fonts
2023-04-01 tweak joycon fit, add joycon tablet edition, generic speaker holes for telescopic, pocket for telescopic mode. Add Sia logos
2023-04-30 tweak some of the universal adapters
2023-05-02 publish v0.4 with telescopic adapters
2023-06-17 Deleted the committed BOSL2 files in preparation to using git submodules instead
2023-06-17 Updated BOSL2, now using git submodule
    Note: git does NOT like keeping both the earlier committed files and the submodule under the same name: checkouts of older commits fail since it'd have to delete what are effectively untracked files.
2023-06-17 Updated BOSL2 dependency
2023-06-17 README: changed instructions to only use git and added --recurse-submodules
2023-06-17 Soft case: Added toggles for the serrated power button texture, exposed button protrusion in customizer
2023-06-17 $fn now defaults to highFn, replaced arbitrary $fn values by either the lowFn or the highFn variables
2023-06-17 Added render quality selector
2023-06-17 phone_case.json: added camera_block_style values
2023-06-17 Customizer: added several step size values per OpenSCAD user manual
2023-06-17 Customizer: expanded camera block support
2023-06-17 phone_case.json: added Pixel 5
2023-06-17 Customizer: added charge port and camera cutout bevel angles
2023-06-17 Bottom speaker cutouts positioning fix
2023-06-17 Use an expanded camera bar as part of the shell model if the bar protrudes out of the case
2023-06-17 phone_case.scad: added missing button_protrusion limits
2023-06-17 Added "combine fingerprint and camera opening" option - works particulaly well on thicker cases for something like the Pixel 5.
2023-06-17 soft_cut(): added usb_cut_height, split horizontal and vertical clearance parameters
2023-06-17 Soft buttons rework, button padding now in the Customizer
2023-06-17 ﻿phone_case.json: added Pixel 7
2023-06-24 documentation
2023-06-29 Changed default set model to "DO NOT USE"
2023-06-29 Split "old" 2022-11 and "new" 2023-06 soft button styles
2023-06-29 phone_case.json: set previously included devices to the older button style
2023-06-29 Pixel 7 now uses rocker notch
2023-06-29 Pixel 5 button tweaks, rocker notch
2023-07-04 tweak rail cut tool
2023-07-05 ﻿phone_case.json added camera cutout bevel angle
2023-07-05 Customizer: added charge port, camera cutout, fingerprint bevel angles
2023-07-05 phone_case.json: renamed button_recess to button_body_protrusion, corrected values
2023-07-05 phone_case.json: Pixel 3XL wall offset percentage
2023-07-05 Soft buttons rework, improved default shape, more configuration options
2023-07-05 phone_case.json: made Pixel 6 case thicker, tweaked buttons
2023-08-12 Pixel 4a tweaks, jungelcat rail rounding, printing guide
2024-02-17 Add Galaxy S23 Ultra
2024-12-05 shop link and theme tweaks
2024-12-05 head button width
2024-12-18 Create CNAME
2025-01-03 update website links
2025-01-03 fix url
2025-01-04 replace website theme with Just The Docs
2025-01-05 minor website updates
2025-01-08 gemfile to run locally, readme
2025-01-08 doc updates and img alt text
2025-01-09 update link
2025-01-09 tweak joycon adapter, tighten joycon rail, add speaker slots, failsafe for button_cut_rounding, add test mode for openscad viewing
2025-01-09 debug views, tweak colors
2025-01-09 debug view for cuts
2025-01-10 rail cut tool guide
2025-01-12 joycon2 support
2025-01-12 cut colors
2025-01-16 add notes to json, disable soft build of galaxy 23 ultra
2025-01-20 kramdown for callouts, remove old theme files
2025-01-20 image alt tags
2025-02-08 xperia 1 v and enable lanyard
2025-02-15 more bevel on holes for side fingerprint sensors
2025-02-15 xpera 1 v tweaks
2025-02-16 usb vertical offset
2025-02-16 headphone vertical offset
2025-02-16 more settings for fingerprint bevel
2025-02-16 xperia 1 v tweaks
2025-02-16 xperia 1 v tweaks - camera, buttons, body length
2025-03-02 tweak button cutout and their manual supports
2025-04-13 more bevel for USB and headphone cuts on Junglecat
2025-04-26 joycon body z adjustment
2025-05-02 reduce screen lip with shimmy. Colors. Experimental configs.
2025-05-20 tune speaker slots
2025-05-20 move rotation to 3d print tab
2025-05-28 changing how shell is positioned and screen lip generated
2025-06-01 fix junglecat position and tweak junglecat rail thickness
2025-06-05 centerline calc
2025-06-05 joycon thickness calc
2025-06-06 screen cut alignment
2025-06-06 shell centerline
2025-06-06 align screen angled bezel
2025-06-08 remove shimmy
2025-06-10 render
2025-06-28 joycon 2 shape, joycon 1 size tweak
2025-08-03 double magnets, skeletonize slider option
2025-08-03 shorter build script for validation
2025-08-08 comments, move test build sh
2025-08-11 add pixel 9a
2025-08-12 pixel 9a tweaks for hard shell
2025-08-19 joycon 2 tweak, rear chamfer
2026-01-03 tool for installing magnets
2026-01-03 mp3 player config
2026-01-03 mp3 player tweaks
2026-01-03 small text
2026-01-04 allow shrinking back face thickness
2026-01-04 hinges
2026-01-07 teardrop hinge hole
2026-01-16 tapered hinge joint

Notices in the files:
avr-gamepad.kicad_pcb:
License: CC BY  4.0
pcb/avr-gamepad.kicad_pcb:
https://creativecommons.org/licenses/by/4.0
